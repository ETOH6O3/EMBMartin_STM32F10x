# Keil uVision project project.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER, STM32_DEVICE_HEADER=stm32f10x.h, ETL_PROFILE="my_etl_profile.h"
  c misc: -Wno-c++20-extensions -Wno-c99-designator
  c include: ..\..\include;..\..\platform\Start;..\..\platform\User;..\..\platform\Library;..\..\platform\System;..\..\TPL\ETL\include;..\..\TPL
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../../platform/User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ./: main.cpp
  group Start
    ../../platform/Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ../../platform/Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ../../platform/System/: cdelay.c cdelay.h
  group EMBMartin
    ../../src/hal/gpio/: basic_tools.cpp outpin.cpp inpin.cpp
    ../../include/EMBMartin/hal/gpio/: basic_tools.h inpin.h outpin.h
    ../../include/EMBMartin/algorithm/: coordinate.h mmath.h PID.h
    ../../src/hal/peripheral/: I2C.cpp PWM.cpp TIM.cpp USART.cpp EXTI.cpp
    ../../include/EMBMartin/hal/peripheral/: I2C.h PWM.h TIM.h USART.h EXTI.h
    ../../include/EMBMartin/: macro.h EMBMartin.h
    ../../include/EMBMartin/lang/: meta.h stream.h fmt.h functional.h inspect.h mstring.h
    ../../src/device/: OLED.cpp breathing_led.cpp mpu6050.cpp ultrasonic_sensor.cpp rotary_encoder.cpp counter_sensor.cpp dc_motor_driver.cpp
    ../../include/EMBMartin/device/: OLED.h debugger.h ultrasonic_sensor.h
    ../../include/EMBMartin/device/oled/: OLED_Font.h OLEDutility.h
    ../../src/algorithm/: PID.cpp angle_filter.cpp
    ../../src/hal/: system.cpp _syscalls.c delay.cpp
    ../../include/EMBMartin/hal/: system.h
    ../../src/app/: balanced_car.cpp
    ../../src/lang/: fmt.cpp stream.cpp mstring.cpp
    ../../include/EMBMartin/app/: balanced_car.h
